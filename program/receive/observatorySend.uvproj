# Keil uVision project observatorySend.uvproj, settings and files
target observatoryRecieve (MCS-51)
  device: STC8H1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: observatoryRecieve +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c
  group Hardware
    ./: SI24R1.c SI24R1.h SPI.c SPI.h USART.c USART.h
